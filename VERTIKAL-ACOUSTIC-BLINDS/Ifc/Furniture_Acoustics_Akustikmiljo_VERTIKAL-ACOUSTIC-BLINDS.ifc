Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Acoustics_Akustikmiljo_VERTIKAL-ACOUSTIC-BLINDS.ifc
Time: 2020-05-06T08:02:06
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: VERTIKAL ACOUSTIC BLINDS
ePset_BIMobjectScript - LOD: 300; Length: 0.0015; Rail length: 0.0015
ePset_BIMobject_BO - ProductName (BO_prodinfo): VERTIKAL ACOUSTIC BLINDS; SKU (BO_prodsku): VERTIKAL-ACOUSTIC-BLINDS; ManufacturName (BO_Manufac): Akustikmiljö; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/akustikmiljo/product/VERTIKAL-ACOUSTIC-BLINDS; ProductDataUrl (BO_prodaturl): bimobject.com/akustikmiljo/product/VERTIKAL-ACOUSTIC-BLINDS; ProductUrl (BO_producturl): https://www.amacoustics.com/products/vertikal-acoustic-blinds; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Acoustics; BimObjectCategoryCode (BO_bocat_code): furniture-acoustics; IfcClassification (BO_ifcclas): Furniture; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
